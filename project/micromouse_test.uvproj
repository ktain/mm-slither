# Keil uVision project micromouse_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: micromouse_test +hex
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\ST_Libraries\inc;..\ST_Libraries\src;..\ST_Libraries\startup;..\user;..\obj;..\project;..\user_Libraries\inc;..\user_Libraries\src;C:\Keil\ARM\RV31\INC;C:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ST_Libraries
    ../ST_Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../ST_Libraries/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group user
    ../user/: main.c stm32f4xx_it.c stm32f4xx_conf.h stm32f4xx_it.h
  group user_Libraries_inc
    ../user_Libraries/inc/: delay.h led.h button.h usart.h pwm.h buzzer.h encoder.h adc.h sensor_Function.h main.h global.h config.h test.h pid.h turn.h align.h speedProfile.h maze.h
  group user_Libraries_src
    ../user_Libraries/src/: delay.c led.c button.c usart.c pwm.c buzzer.c encoder.c adc.c sensor_Function.c test.c turn.c align.c speedProfile.c floodCenter.c move.c lookup.c graphics.c initializeGrid.c
  group start_up
    ../ST_Libraries/startup/: startup_stm32f4xx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
